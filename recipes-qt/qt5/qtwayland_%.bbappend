# SPDX-License-Identifier: MIT
#
# Copyright (C) 2023 He Yong <hyyoxhk@163.com>
#

PACKAGECONFIG = " \
    wayland-client \
    wayland-server \
    wayland-egl \
"
