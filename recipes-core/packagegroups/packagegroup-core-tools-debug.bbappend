RDEPENDS:${PN} += " \
    libubootenv-bin \
    swupdate-www \
    openssh-sftp-server \
    glmark2 \
    libgpiod-tools \
"
