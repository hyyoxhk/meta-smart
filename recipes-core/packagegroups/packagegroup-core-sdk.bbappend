# SPDX-License-Identifier: MIT
#
# Copyright (C) 2023 He Yong <hyyoxhk@163.com>
#

RDEPENDS:packagegroup-core-sdk += " \
    packagegroup-qt5-toolchain-target \
    wayland-tools \
    cmake \
    meson \
    git \
"
